# Keil uVision project Lab.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Lab1
    ./Lab 1/: bai1.s bai2.s bai3.s bai4.s bai5.s bai6.s bai8.s bai7.s
  group Lab2
    ./Lab2/: lab2_khung.s lab2_bai1.s lab2_bai2.s lab2_bai3.s lab2_bai4.s lab2_bai5.s lab2_bai6.s lab2_bai7.s lab2_bai8.s
  group Lab3
    ./Lab3/: lab3_bai1a.s lab3_bai1b.s lab3_bai1c.s lab3_bai1d.s lab3_bai1e.s lab3_bai1f.s lab3_bai1g.s lab3_bai1h.s lab3_bai2a.s lab3_bai2b.s lab3_bai2c.s lab3_bai2d.s lab3_bai2e.s lab3_bai2f.s lab3_bai2g.s lab3_bai2h.s lab3_bai3.s
  group Lab5
    ./Lab5/: 16_2.s 16_8.s lab5_bai2.s lab5_bai3.s lab5_bai4.s 2_8.s
  group Lab6
    ./Lab6/: lab6_bai1.s lab6_bai2.s lab6_bai3.s lab6_bai3b.s lab6_bai4.s lab6_bai5.s
  group Lab7
    ./Lab7/: lab7_bai1.s lab7_bai2.s lab7_bai3.s
  group Lab8
    ./Lab8/: lab8_bai1.s lab8_bai2.s lab8_bai3.s
